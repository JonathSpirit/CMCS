# Keil uVision project testuc.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F38C Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x07FF) IROM(0-0x3FFF) CLOCK(48000000)
  output: testuc +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
